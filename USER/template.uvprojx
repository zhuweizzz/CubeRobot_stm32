# Keil uVision project template.uvprojx, settings and files
target Template (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\CORE;..\USER;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\SYSTICK;..\HARDWARE\PWM;..\HARDWARE\USART;..\HARDWARE\ADC;..\HARDWARE\LCD;..\HARDWARE\CUBE;..\HARDWARE\ROBOT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_i2c.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_adc.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SYSTICK/: systick.c
    ../HARDWARE/I2C/: i2c.c
    ../HARDWARE/USART/: usart1.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/CUBE/: pwm1.c pwm2.c pwm3.c pwm4.c pwm5.c pwm6.c pwm7.c pwm8.c motor.c
    ../HARDWARE/ROBOT/: robot.c
